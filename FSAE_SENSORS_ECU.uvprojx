# Keil uVision project FSAE_SENSORS_ECU.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FSAE_SENSORS_ECU
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: .;..;..\..\..\..;D:\rtos\FreeRTOSv9.0.0\FreeRTOS;D:\rtos\FreeRTOSv9.0.0\FreeRTOS\Source\include;D:\rtos\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM4F;D:\ti\TivaWare_C_Series-2.1.3.156\inc;D:\ti\TivaWare_C_Series-2.1.3.156\;D:\ti\TivaWare_C_Series-2.1.3.156\driverlib;D:\ti\TivaWare_C_Series-2.1.3.156\driverlib\rvmdk;D:\ti\TivaWare_C_Series-2.1.3.156\usblib;D:\ti\TivaWare_C_Series-2.1.3.156\utils
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\FSAE_SENSORS_ECU.sct
  link misc: --entry Reset_Handler
  group Source
    ./: main.c i2cDriver.c i2cDriver.h lcd_i2c.c lcd_i2c.h lcd_task.c lcd_task.h adc_api.c adc_api.h ADC_task.c ADC_task.h delay.c delay.h startup_rvmdk.S FreeRTOSConfig.h priorities.h sensors.c sensors.h
    D:/ti/TivaWare_C_Series-2.1.3.156/utils/: uartstdio.c ustdlib.c
  group Drivers Libraries
    D:/ti/TivaWare_C_Series-2.1.3.156/driverlib/rvmdk/: driverlib.lib
  group FreeRTOS
    D:/rtos/FreeRTOSv9.0.0/FreeRTOS/Source/: tasks.c croutine.c event_groups.c list.c queue.c timers.c
    D:/rtos/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
    D:/rtos/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.0.2
